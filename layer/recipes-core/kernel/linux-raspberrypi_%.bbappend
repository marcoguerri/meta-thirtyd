FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

CMDLINE+="initcall_debug"
